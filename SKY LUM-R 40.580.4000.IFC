Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SKY LUM-R 40.580.4000.IFC
Time: 2023-11-03T07:50:15
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: SKY LUM-R 40.580.4000
In: Default Storey
SolidWorks Custom Properties - Description: PWR(40W);LUM.FLUX(4000lm)
PSet_Mass_Property - Mass Measure: 3.96312; Area Measure: 0.555748 m2; Volume Measure: 0.00396312 m3
